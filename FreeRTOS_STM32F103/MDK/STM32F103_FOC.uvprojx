# Keil uVision project STM32F103_FOC.uvprojx, settings and files
target STM32_FOC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103_FOC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CMSIS_STM32F103ZET6\CORE;..\CMSIS_STM32F103ZET6\FWLIB\inc;..\CMSIS_STM32F103ZET6\USER;..\RTOS\include;..\SRC\inc;..\DEV\inc;..\PUB\inc;..\HAL\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ../CMSIS_STM32F103ZET6/CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../CMSIS_STM32F103ZET6/FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../CMSIS_STM32F103ZET6/USER/: stm32f10x_it.c system_stm32f10x.c
  group DEV
    ../DEV/src/: dev_sysTick.c dev_led.c dev_beep.c
  group HAL
    ../HAL/src/: hal_uart.c hal_adc.c
  group PUB
    ../PUB/: log.c
  group RTOS
    ../RTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../RTOS/portable/MemMang/: heap_4.c
    ../RTOS/portable/RVDS/ARM_CM3/: port.c
  group SRC
    ../SRC/: main.c system.c
  group README
    ../README/: readme.txt
